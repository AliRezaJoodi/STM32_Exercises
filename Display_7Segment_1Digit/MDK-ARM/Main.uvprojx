# Keil uVision project Main.uvprojx, settings and files
target Main (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Main +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,STM32F103xB
  c include: ..\Core;..\..\_Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\_Drivers\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f103xb.s
  group Drivers
    ../UserCode/: system_stm32f1xx.c STM32F1xx_USART_BareMetal.c Display_7Segment_1Digit.c
  group UserCode
    ../UserCode/: Main.c _SystemClock.c _USART.c
software components: CMSIS:CORE 5.6.0
