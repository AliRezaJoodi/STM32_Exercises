# Keil uVision project Main.uvprojx, settings and files
target Main (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Main +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32F103xB,HSE_VALUE=8000000,HSI_VALUE=8000000,LSE_VALUE=32768,LSI_VALUE=40000
  c include: ..\Core\Inc;..\..\_ExtraDrivers\Inc;..\..\_Drivers\CMSIS\Include;..\..\_Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\_Drivers\STM32F1xx_HAL_Driver\Inc;..\..\_Drivers\STM32F1xx_HAL_Driver\Inc\Legacy
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_bm_it.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../_Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_adc.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_gpio.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_usart.c stm32f1xx_ll_utils.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/ExtraDrivers
    ../../_ExtraDrivers/Src/: stm32f1xx_bm_adc.c stm32f1xx_bm_bus.c stm32f1xx_bm_exti.c stm32f1xx_bm_gpio.c stm32f1xx_bm_pwr.c stm32f1xx_bm_rcc.c stm32f1xx_bm_timer_systick.c stm32f1xx_bm_usart.c
software components: CMSIS:CORE 5.6.0
